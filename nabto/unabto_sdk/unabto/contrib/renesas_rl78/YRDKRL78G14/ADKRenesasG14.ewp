# IAR project ADKRenesasG14.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F104PJ RL78 - R5F104PJ
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 1024
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: USE_SPI
  ICCRL78.CCDiagSuppress: Pa050
  ICCRL78.CCIncludePath2: $PROJ_DIR$; ..; ..\Apps; drv; applilet3_src; ..\..\..\src
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkr5f104pj.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group applilet3_src
    applilet3_src/: r_cg_serial.c r_cg_serial.h r_cg_serial_user.c
  group Apps
    ../Apps/: App_Common.c App_Connect.c App_Nabto.c App_ProgramMode.c App_Startup.c Apps.h NVSettings.c NVSettings.h unabto_application.c unabto_config.h
  group CmdLib
    ../CmdLib/: AtCmdLib.c AtCmdLib.h GainSpan_SPI.c GainSpan_SPI.h
  group sensors
    ../sensors/: Accelerometer.c Accelerometer.h LightSensor.c LightSensor.h Potentiometer.c Potentiometer.h Temperature.c Temperature.h
  group unabto
    ../../../src/unabto/: unabto.h unabto_aes128_sha256.c unabto_aes128_sha256.h unabto_aes_cbc.h unabto_app.h unabto_app_adapter.c unabto_app_adapter.h unabto_attach.c unabto_attach.h unabto_common_main.c unabto_common_main.h unabto_config_defaults.h unabto_config_derived.h unabto_connection.c unabto_connection.h unabto_connection_type.h unabto_context.c unabto_context.h unabto_crypto.c unabto_crypto.h unabto_env_base.h unabto_environment.h unabto_external_environment.h unabto_hmac_sha256.h unabto_include_platform.h unabto_logging.h unabto_main_contexts.h unabto_memory.h unabto_message.c unabto_message.h unabto_next_event.c unabto_packet.c unabto_packet.h unabto_packet_util.c unabto_packet_util.h unabto_prf.c unabto_prf.h unabto_protocol_defines.h unabto_protocol_exceptions.h unabto_stream.c unabto_stream.h unabto_stream_event.c unabto_stream_event.h unabto_util.h
    ../../../src/platforms/renesas_rl78/: unabto_env_base_renesas_rl78.h unabto_external_environment_renesas_rl78.c unabto_logging_renesas_rl78.c unabto_logging_renesas_rl78.h
  group unabto/util
    ../../../src/unabto/util/: unabto_buffer.c unabto_buffer.h unabto_queue.c unabto_queue.h
  group YRDKRL78G14/drv
    drv/: ADC.c ADC.h I2C.c I2C.h led.c led.h RDKRL78_spi.c RDKRL78_spi.h SAU.h SPI _G14.c SPI.h Timer.c Timer.h UART0.c UART0.h UART2.c UART2.h
  group YRDKRL78G14/drv/Glyph
    drv/Glyph/: Glyph_API.h Glyph_cfg.h glyph_register.c glyph_types.h lcd.c lcd.h RL78GlyphLib_Debug.r87
  group YRDKRL78G14/drv/Glyph/Drivers
    drv/Glyph/Drivers/: ST7579_LCD.h
  group YRDKRL78G14/init
    init/: hwsetup.c hwsetup.h
  group YRDKRL78G14/system
    system/: console.c console.h EEPROM.c EEPROM.h GainSpan_IO.c GainSpan_IO.h mstimer.c mstimer.h platform.h Switch.c Switch.h YRDKRL78G14.h
